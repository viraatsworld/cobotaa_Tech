Commit message: update collision between tooltip

File: cvrb0609_description/urdf/example_cvrb0609.urdf (robot description, URDF)
Before this commit: robot cobotta_pro, 11 links, 10 joints
Joints:
- joint schmalz_ecbpmi_tip_joint: parent schmalz_ecbpmi_base_link -> schmalz_ecbpmi_body_link
